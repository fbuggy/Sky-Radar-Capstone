options:
  parameters:
    author: finnb
    generate_options: qt_gui
    id: basic
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: LO_1_RX
  id: variable
  parameters:
    value: '2000000000'
  states: {}
- name: LO_2_TX
  id: variable
  parameters:
    value: '2000000000'
  states: {}
- name: PLUTO1_IIO
  id: variable
  parameters:
    value: '"TODO"'
  states: {}
- name: PLUTO2_IIO
  id: variable
  parameters:
    value: '"TODO"'
  states: {}
- name: modulation_period
  id: variable
  parameters:
    value: '0.00050'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5000000'
  states: {}
- name: samples_per_ramp
  id: variable
  parameters:
    value: (int)(modulation_period*samp_rate)
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: samples_per_ramp
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1'
    type: complex
    vlen: samples_per_ramp
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: samples_per_ramp
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: samples_per_ramp
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: samples_per_ramp
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hanning(samples_per_ramp)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: LO_2_TX
    samplerate: samp_rate
    type: fc32
    uri: PLUTO2_IIO
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: LO_1_RX
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: PLUTO1_IIO
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: samples_per_ramp
    x_axis_label: '"Frequency"'
    x_start: '0'
    x_step: samp_rate/samples_per_ramp
    x_units: '"Hz"'
    y_axis_label: '""'
    y_units: '"dB"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
